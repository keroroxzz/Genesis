Commit message: Add Draft of Sensor Link for URDF

File: genesis/assets/urdf/go2/urdf/go2.urdf (robot description, URDF)
Before this commit: robot go2_description, 29 links, 28 joints
Links:
- removed link radar
